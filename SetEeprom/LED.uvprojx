# Keil uVision project LED.uvprojx, settings and files
target LED (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F071VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: .\User;.\Systerm;.\Library\inc;.\Hardwork\24CXX;.\Hardwork\IIC;.\Hardwork\LCD;.\Hardwork\LED;.\Systerm\Delay;.\Library\inc;.\Systerm\Sys;.\Hardwork\24CXX
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./User/: main.c
  group Hardwork
    ./Hardwork/LCD/: LCD.c
    ./Hardwork/LED/: led.c
    ./Hardwork/24CXX/: 24cxx.c
    ./Hardwork/IIC/: myiic.c
  group Systerm
    ./Systerm/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s
    ./Systerm/Delay/: delay.c
    ./Systerm/Sys/: sys.c
  group Library
    ./Library/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
